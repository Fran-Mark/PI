options:
  parameters:
    author: fran
    generate_options: qt_gui
    id: doa_emulador_arreglo
    output_language: python
    title: DoA de señales adquiridas con emulador de arreglo
  states: {}

blocks:
- name: element_separation
  id: variable
  parameters:
    value: 0.5*299792458/fc
  states: {}
- name: fs
  id: variable
  parameters:
    value: 65e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: beamforming_doaesprit_py_cf_0
  id: beamforming_doaesprit_py_cf
  parameters:
    element_separation: element_separation
    fc: fc
    mx: mx
    my: my
    n: '1'
    spd: '128'
  states: {}
- name: beamforming_randomsampler_0
  id: beamforming_randomsampler
  parameters:
    decimation: '8'
    vlen: mx*my
  states: {state: disabled}
- name: beamforming_randomsampler_1
  id: beamforming_randomsampler
  parameters:
    decimation: '8'
    vlen: '16'
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-8191.5'
    type: float
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    num_streams: '16'
    type: complex
  states: {}
- name: blocks_deinterleave_0_0
  id: blocks_deinterleave
  parameters:
    num_streams: '16'
    type: float
  states: {}
- name: blocks_deinterleave_1
  id: blocks_deinterleave
  parameters:
    num_streams: '16'
    type: float
  states: {state: disabled}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
    vlen: '16'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /media/fran/46FAA90DFAA8FA77/Ventanas/IB/PI/etc/output
    type: complex
    vlen: '16'
  states: {}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    file: /media/fran/46FAA90DFAA8FA77/Ventanas/IB/PI/GitHub/DOA/test/submuestreada_real_trimmed.npy
    offset: '32'
    repeat: 'True'
    type: float
  states: {state: disabled}
- name: blocks_file_source_0_0_0_0_0
  id: blocks_file_source
  parameters:
    file: /media/fran/46FAA90DFAA8FA77/Ventanas/IB/PI/GitHub/DOA/test/real_frec_0_complex.npy
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0_1
  id: blocks_file_source
  parameters:
    file: /media/fran/46FAA90DFAA8FA77/Ventanas/IB/PI/GitHub/DOA/test/remake_desde_csv.npy
    offset: '64'
    repeat: 'True'
    type: short
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters:
    vlen: '16'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2/8192
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: '16'
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
    vlen: '16'
  states: {state: disabled}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '16'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '16'
    type: float
  states: {state: disabled}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '16'
    type: complex
  states: {}
- name: blocks_streams_to_vector_0_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '16'
    type: float
  states: {state: disabled}
- name: blocks_streams_to_vector_0_1
  id: blocks_streams_to_vector
  parameters:
    num_streams: '16'
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: short
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '16'
    type: complex
  states: {}
- name: fc
  id: parameter
  parameters:
    label: Carrier frequency
    type: eng_float
    value: 146e6
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0_0_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0_0_0_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0_0_0_0_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0_0_0_0_1
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0_0_0_0_1_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0_0_0_0_1_0_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0_0_0_0_1_0_0_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0_0_0_0_1_0_0_0_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0_0_0_0_1_0_0_0_0_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0_0_0_0_1_0_0_0_0_0_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_1
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_1_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: mx
  id: parameter
  parameters:
    label: '# elements in x'
    type: intx
    value: '4'
  states: {}
- name: my
  id: parameter
  parameters:
    label: '# elements in y'
    type: intx
    value: '4'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: fs
    fc: '0'
    fftsize: '1024'
    name: '"Con deinterleave"'
    plotwaterfall: 'False'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: fs
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: float_samples_stream
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: float_samples_stream
  states: {state: disabled}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: complex_samples_vector
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: complex_samples_vector
  states: {state: disabled}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: complex_samples_vector
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: float_samples_stream
  states: {state: disabled}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: float_samples_stream
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: complex_samples_vector
  states: {}

connections:
- [beamforming_doaesprit_py_cf_0, doa_port, blocks_message_debug_0, print]
- [beamforming_randomsampler_0, '0', beamforming_doaesprit_py_cf_0, '0']
- [beamforming_randomsampler_1, '0', beamforming_doaesprit_py_cf_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_deinterleave_0, '0', blocks_streams_to_vector_0, '0']
- [blocks_deinterleave_0, '1', blocks_streams_to_vector_0, '1']
- [blocks_deinterleave_0, '10', blocks_streams_to_vector_0, '10']
- [blocks_deinterleave_0, '11', blocks_streams_to_vector_0, '11']
- [blocks_deinterleave_0, '12', blocks_streams_to_vector_0, '12']
- [blocks_deinterleave_0, '13', blocks_streams_to_vector_0, '13']
- [blocks_deinterleave_0, '14', blocks_streams_to_vector_0, '14']
- [blocks_deinterleave_0, '15', blocks_streams_to_vector_0, '15']
- [blocks_deinterleave_0, '2', blocks_streams_to_vector_0, '2']
- [blocks_deinterleave_0, '2', qtgui_sink_x_1, '0']
- [blocks_deinterleave_0, '3', blocks_streams_to_vector_0, '3']
- [blocks_deinterleave_0, '4', blocks_streams_to_vector_0, '4']
- [blocks_deinterleave_0, '5', blocks_streams_to_vector_0, '5']
- [blocks_deinterleave_0, '6', blocks_streams_to_vector_0, '6']
- [blocks_deinterleave_0, '7', blocks_streams_to_vector_0, '7']
- [blocks_deinterleave_0, '8', blocks_streams_to_vector_0, '8']
- [blocks_deinterleave_0, '9', blocks_streams_to_vector_0, '9']
- [blocks_deinterleave_0_0, '0', hilbert_fc_0, '0']
- [blocks_deinterleave_0_0, '1', hilbert_fc_0_0_0_0_0_0_0, '0']
- [blocks_deinterleave_0_0, '10', hilbert_fc_0_0_0_0_0_0_1_0_0, '0']
- [blocks_deinterleave_0_0, '11', hilbert_fc_0_0_0_0_0_0_1_0_0_0, '0']
- [blocks_deinterleave_0_0, '12', hilbert_fc_0_0_0_0_0_0_1_0_0_0_0_0, '0']
- [blocks_deinterleave_0_0, '13', hilbert_fc_0_0_0_0_0_0, '0']
- [blocks_deinterleave_0_0, '14', hilbert_fc_0_0_0_0_0_0_1_0_0_0_0_0_0, '0']
- [blocks_deinterleave_0_0, '15', hilbert_fc_0_0_0_0_0_0_1_0_0_0_0, '0']
- [blocks_deinterleave_0_0, '2', hilbert_fc_0_0_0_0_0, '0']
- [blocks_deinterleave_0_0, '3', hilbert_fc_0_0_0_0, '0']
- [blocks_deinterleave_0_0, '4', hilbert_fc_0_0_0, '0']
- [blocks_deinterleave_0_0, '5', hilbert_fc_0_0, '0']
- [blocks_deinterleave_0_0, '6', hilbert_fc_0_0_1, '0']
- [blocks_deinterleave_0_0, '7', hilbert_fc_0_0_1_0, '0']
- [blocks_deinterleave_0_0, '8', hilbert_fc_0_0_0_0_0_0_1, '0']
- [blocks_deinterleave_0_0, '9', hilbert_fc_0_0_0_0_0_0_1_0, '0']
- [blocks_deinterleave_1, '0', blocks_streams_to_vector_0_0, '0']
- [blocks_deinterleave_1, '0', qtgui_sink_x_0, '0']
- [blocks_deinterleave_1, '1', blocks_streams_to_vector_0_0, '1']
- [blocks_deinterleave_1, '10', blocks_streams_to_vector_0_0, '10']
- [blocks_deinterleave_1, '11', blocks_streams_to_vector_0_0, '11']
- [blocks_deinterleave_1, '12', blocks_streams_to_vector_0_0, '12']
- [blocks_deinterleave_1, '13', blocks_streams_to_vector_0_0, '13']
- [blocks_deinterleave_1, '14', blocks_streams_to_vector_0_0, '14']
- [blocks_deinterleave_1, '15', blocks_streams_to_vector_0_0, '15']
- [blocks_deinterleave_1, '2', blocks_streams_to_vector_0_0, '2']
- [blocks_deinterleave_1, '3', blocks_streams_to_vector_0_0, '3']
- [blocks_deinterleave_1, '4', blocks_streams_to_vector_0_0, '4']
- [blocks_deinterleave_1, '5', blocks_streams_to_vector_0_0, '5']
- [blocks_deinterleave_1, '6', blocks_streams_to_vector_0_0, '6']
- [blocks_deinterleave_1, '7', blocks_streams_to_vector_0_0, '7']
- [blocks_deinterleave_1, '8', blocks_streams_to_vector_0_0, '8']
- [blocks_deinterleave_1, '9', blocks_streams_to_vector_0_0, '9']
- [blocks_delay_0_0, '0', blocks_float_to_complex_0_0, '1']
- [blocks_file_source_0_0_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_file_source_0_0_0_0_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_file_source_0_0_1, '0', blocks_throttle_1, '0']
- [blocks_float_to_complex_0_0, '0', virtual_sink_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', virtual_sink_0, '0']
- [blocks_short_to_float_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_stream_to_vector_0, '0', virtual_sink_0_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_delay_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_null_sink_0, '0']
- [blocks_streams_to_vector_0_0, '0', blocks_null_sink_1, '0']
- [blocks_streams_to_vector_0_1, '0', virtual_sink_1_0, '0']
- [blocks_throttle_0_0, '0', virtual_sink_0_0, '0']
- [blocks_throttle_0_0_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle_1, '0', blocks_short_to_float_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_deinterleave_0, '0']
- [hilbert_fc_0, '0', blocks_streams_to_vector_0_1, '0']
- [hilbert_fc_0_0, '0', blocks_streams_to_vector_0_1, '5']
- [hilbert_fc_0_0_0, '0', blocks_streams_to_vector_0_1, '4']
- [hilbert_fc_0_0_0_0, '0', blocks_streams_to_vector_0_1, '3']
- [hilbert_fc_0_0_0_0_0, '0', blocks_streams_to_vector_0_1, '2']
- [hilbert_fc_0_0_0_0_0_0, '0', blocks_streams_to_vector_0_1, '13']
- [hilbert_fc_0_0_0_0_0_0_0, '0', blocks_streams_to_vector_0_1, '1']
- [hilbert_fc_0_0_0_0_0_0_1, '0', blocks_streams_to_vector_0_1, '8']
- [hilbert_fc_0_0_0_0_0_0_1_0, '0', blocks_streams_to_vector_0_1, '9']
- [hilbert_fc_0_0_0_0_0_0_1_0_0, '0', blocks_streams_to_vector_0_1, '10']
- [hilbert_fc_0_0_0_0_0_0_1_0_0_0, '0', blocks_streams_to_vector_0_1, '11']
- [hilbert_fc_0_0_0_0_0_0_1_0_0_0_0, '0', blocks_streams_to_vector_0_1, '15']
- [hilbert_fc_0_0_0_0_0_0_1_0_0_0_0_0, '0', blocks_streams_to_vector_0_1, '12']
- [hilbert_fc_0_0_0_0_0_0_1_0_0_0_0_0_0, '0', blocks_streams_to_vector_0_1, '14']
- [hilbert_fc_0_0_1, '0', blocks_streams_to_vector_0_1, '6']
- [hilbert_fc_0_0_1_0, '0', blocks_streams_to_vector_0_1, '7']
- [virtual_source_0_0, '0', blocks_deinterleave_1, '0']
- [virtual_source_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [virtual_source_0_0_0, '0', blocks_deinterleave_0_0, '0']
- [virtual_source_1, '0', beamforming_randomsampler_0, '0']
- [virtual_source_1, '0', beamforming_randomsampler_1, '0']
- [virtual_source_1, '0', blocks_file_sink_0, '0']
- [virtual_source_1, '0', blocks_vector_to_stream_0_0, '0']

metadata:
  file_format: 1
