options:
  parameters:
    author: fran
    generate_options: qt_gui
    id: doa_emulador_arreglo
    output_language: python
    title: DoA de señales adquiridas con emulador de arreglo
  states: {}

blocks:
- name: element_separation
  id: variable
  parameters:
    value: 0.5*299792458/fc
  states: {}
- name: fs
  id: variable
  parameters:
    value: 65e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: beamforming_doaesprit_py_cf_0
  id: beamforming_doaesprit_py_cf
  parameters:
    element_separation: element_separation
    fc: fc
    mx: mx
    my: my
    n: '1'
    spd: '128'
  states: {}
- name: beamforming_randomsampler_0
  id: beamforming_randomsampler
  parameters:
    decimation: '8'
    vlen: mx*my
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-8191.5'
    type: float
  states: {state: disabled}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    num_streams: '16'
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
    vlen: '16'
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /media/fran/46FAA90DFAA8FA77/Ventanas/IB/PI/capturas-jose/20201117_120307_sin_header
    repeat: 'True'
    type: short
  states: {state: disabled}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /run/media/fran/46FAA90DFAA8FA77/Ventanas/IB/PI/GitHub/DOA/test/submuestreada_complex_trimmed.npy
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    vlen: '16'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2/8192
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: '16'
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '16'
    type: complex
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '16'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fc
  id: parameter
  parameters:
    label: Carrier frequency
    type: eng_float
    value: 146e6
  states: {}
- name: mx
  id: parameter
  parameters:
    label: '# elements in x'
    type: intx
    value: '4'
  states: {}
- name: my
  id: parameter
  parameters:
    label: '# elements in y'
    type: intx
    value: '4'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: fs
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: fs
    type: complex
    ylabel: Real
  states: {}

connections:
- [beamforming_doaesprit_py_cf_0, doa_port, blocks_message_debug_0, print]
- [beamforming_randomsampler_0, '0', beamforming_doaesprit_py_cf_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_deinterleave_0, '0', blocks_streams_to_vector_0, '0']
- [blocks_deinterleave_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_deinterleave_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_deinterleave_0, '1', blocks_streams_to_vector_0, '1']
- [blocks_deinterleave_0, '10', blocks_streams_to_vector_0, '10']
- [blocks_deinterleave_0, '11', blocks_streams_to_vector_0, '11']
- [blocks_deinterleave_0, '12', blocks_streams_to_vector_0, '12']
- [blocks_deinterleave_0, '13', blocks_streams_to_vector_0, '13']
- [blocks_deinterleave_0, '14', blocks_streams_to_vector_0, '14']
- [blocks_deinterleave_0, '15', blocks_streams_to_vector_0, '15']
- [blocks_deinterleave_0, '2', blocks_streams_to_vector_0, '2']
- [blocks_deinterleave_0, '3', blocks_streams_to_vector_0, '3']
- [blocks_deinterleave_0, '4', blocks_streams_to_vector_0, '4']
- [blocks_deinterleave_0, '5', blocks_streams_to_vector_0, '5']
- [blocks_deinterleave_0, '6', blocks_streams_to_vector_0, '6']
- [blocks_deinterleave_0, '7', blocks_streams_to_vector_0, '7']
- [blocks_deinterleave_0, '8', blocks_streams_to_vector_0, '8']
- [blocks_deinterleave_0, '9', blocks_streams_to_vector_0, '9']
- [blocks_delay_0, '0', blocks_float_to_complex_0, '1']
- [blocks_file_source_0_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_0, '0', beamforming_randomsampler_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_deinterleave_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_short_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_stream_to_vector_0, '0', beamforming_randomsampler_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_delay_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_float_to_complex_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_null_sink_0, '0']
- [blocks_throttle_0, '0', blocks_deinterleave_0, '0']
- [blocks_throttle_0, '0', blocks_short_to_float_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
