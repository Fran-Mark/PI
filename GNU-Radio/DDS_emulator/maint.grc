options:
  parameters:
    author: fran
    generate_options: qt_gui
    id: maint
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: 436e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 65e3
  states: {}
- name: beamforming_HeaderReader_0
  id: beamforming_HeaderReader
  parameters: {}
  states: {}
- name: beamforming_beamformer_0
  id: beamforming_beamformer
  parameters:
    idx: '0'
    mx: '2'
    my: '2'
  states: {}
- name: beamforming_doaesprit_py_cf_0
  id: beamforming_doaesprit_py_cf
  parameters:
    element_separation: 0.55*299792458/fc
    fc: fc
    mx: '2'
    my: '2'
    n: '1'
    spd: '128'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: '4'
  states: {}
- name: blocks_short_to_char_0
  id: blocks_short_to_char
  parameters: {}
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '88'
    type: byte
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '4'
    type: complex
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 192.168.0.21
    port: '12345'
    psize: '64088'
    type: short
    vlen: '1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tabs@1
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_1_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tabs@0
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tabs@2
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: stream_demux_stream_demux_0
  id: stream_demux_stream_demux
  parameters:
    lengths: (32000, 44)
    num_outputs: '2'
    type: short
    vlen: '1'
  states: {}
- name: stream_demux_stream_demux_1
  id: stream_demux_stream_demux
  parameters:
    lengths: (4,12)
    num_outputs: '2'
    type: complex
    vlen: '1'
  states: {}
- name: stream_demux_stream_demux_2
  id: stream_demux_stream_demux
  parameters:
    lengths: (1, 1, 1, 1)
    num_outputs: '4'
    type: complex
    vlen: '1'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Offsets
    label1: FFT Beamforming
    label2: Time Beamforming
    num_tabs: '3'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: data
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: data
  states: {}

connections:
- [beamforming_beamformer_0, '0', qtgui_freq_sink_x_0, '0']
- [beamforming_beamformer_0, '0', qtgui_sink_x_1_0_0_0, '0']
- [beamforming_beamformer_0, '0', qtgui_time_sink_x_1, '0']
- [beamforming_doaesprit_py_cf_0, doa_port, beamforming_beamformer_0, doa_port]
- [beamforming_doaesprit_py_cf_0, doa_port, blocks_message_debug_0, print]
- [blocks_interleaved_short_to_complex_0, '0', stream_demux_stream_demux_1, '0']
- [blocks_short_to_char_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_stream_to_vector_1, '0', beamforming_HeaderReader_0, '0']
- [blocks_streams_to_vector_0, '0', beamforming_beamformer_0, '0']
- [blocks_streams_to_vector_0, '0', beamforming_doaesprit_py_cf_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_null_sink_1, '0']
- [blocks_udp_source_0, '0', stream_demux_stream_demux_0, '0']
- [stream_demux_stream_demux_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [stream_demux_stream_demux_0, '1', blocks_short_to_char_0, '0']
- [stream_demux_stream_demux_1, '0', virtual_sink_0, '0']
- [stream_demux_stream_demux_1, '1', blocks_null_sink_0, '0']
- [stream_demux_stream_demux_2, '0', blocks_streams_to_vector_0, '0']
- [stream_demux_stream_demux_2, '0', qtgui_time_sink_x_0, '0']
- [stream_demux_stream_demux_2, '1', blocks_streams_to_vector_0, '1']
- [stream_demux_stream_demux_2, '1', qtgui_time_sink_x_0, '1']
- [stream_demux_stream_demux_2, '2', blocks_streams_to_vector_0, '2']
- [stream_demux_stream_demux_2, '2', qtgui_time_sink_x_0, '2']
- [stream_demux_stream_demux_2, '3', blocks_streams_to_vector_0, '3']
- [stream_demux_stream_demux_2, '3', qtgui_time_sink_x_0, '3']
- [virtual_source_0, '0', stream_demux_stream_demux_2, '0']

metadata:
  file_format: 1
