options:
  parameters:
    author: fran
    generate_options: no_gui
    id: main_cpp
    output_language: cpp
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: short
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 192.168.0.21
    port: '12345'
    psize: '64088'
    type: short
    vlen: '1'
  states: {}

connections:
- [blocks_udp_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
