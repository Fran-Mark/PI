options:
  parameters:
    author: fran
    generate_options: qt_gui
    id: gui_simplificada
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 65e6
  states: {}
- name: beamforming_HeaderReader_0
  id: beamforming_HeaderReader
  parameters: {}
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_short_to_char_0
  id: blocks_short_to_char
  parameters: {}
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '88'
    type: byte
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 192.168.0.21
    port: '12345'
    psize: '64088'
    type: short
    vlen: '1'
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: stream_demux_stream_demux_0
  id: stream_demux_stream_demux
  parameters:
    lengths: (32000, 44)
    num_outputs: '2'
    type: short
    vlen: '1'
  states: {}
- name: stream_demux_stream_demux_1
  id: stream_demux_stream_demux
  parameters:
    lengths: (1,15)
    num_outputs: '2'
    type: complex
    vlen: '1'
  states: {}

connections:
- [blocks_interleaved_short_to_complex_0, '0', qtgui_sink_x_1_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', stream_demux_stream_demux_1, '0']
- [blocks_short_to_char_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_stream_to_vector_1, '0', beamforming_HeaderReader_0, '0']
- [blocks_udp_source_0, '0', stream_demux_stream_demux_0, '0']
- [stream_demux_stream_demux_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [stream_demux_stream_demux_0, '1', blocks_short_to_char_0, '0']
- [stream_demux_stream_demux_1, '0', qtgui_sink_x_1, '0']
- [stream_demux_stream_demux_1, '1', blocks_null_sink_0, '0']

metadata:
  file_format: 1
