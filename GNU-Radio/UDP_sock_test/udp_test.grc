options:
  parameters:
    author: fran
    generate_options: qt_gui
    id: udp_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (92, 92)
    type: complex
  states: {}
- name: network_udp_source_1
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'True'
    port: '7070'
    src_zeros: 'False'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"1 MHz"'
    rate: '100'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"3 MHz"'
    rate: '100'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Completo"'
    type: complex
  states: {}

connections:
- [blocks_stream_demux_0, '0', qtgui_sink_x_0, '0']
- [blocks_stream_demux_0, '1', qtgui_sink_x_0_0, '0']
- [network_udp_source_1, '0', blocks_stream_demux_0, '0']
- [network_udp_source_1, '0', qtgui_sink_x_1, '0']

metadata:
  file_format: 1
