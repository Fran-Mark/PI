options:
  parameters:
    author: fran
    generate_options: qt_gui
    id: udp_packet_size_testing
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7070'
    psize: '4400'
    type: int
    vlen: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Contador
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Testigo
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: float
  states: {}
- name: stream_demux_stream_demux_0
  id: stream_demux_stream_demux
  parameters:
    lengths: (1000, 100)
    num_outputs: '2'
    type: int
    vlen: '1'
  states: {}

connections:
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_int_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_udp_source_0, '0', stream_demux_stream_demux_0, '0']
- [stream_demux_stream_demux_0, '0', blocks_int_to_float_0, '0']
- [stream_demux_stream_demux_0, '1', blocks_int_to_float_0_0, '0']

metadata:
  file_format: 1
