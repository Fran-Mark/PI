options:
  parameters:
    author: fran
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: beamforming_beamformer_0
  id: beamforming_beamformer
  parameters:
    idx: '0'
    mx: '4'
    my: '4'
  states: {}
- name: beamforming_doaesprit_py_cf_0
  id: beamforming_doaesprit_py_cf
  parameters:
    element_separation: (299792458/(2*436e6))
    fc: 436e6
    mx: '4'
    my: '4'
    n: '1'
    spd: '128'
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-8191.5'
    type: float
  states: {}
- name: blocks_deinterleave_0_0
  id: blocks_deinterleave
  parameters:
    num_streams: '16'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /run/media/fran/46FAA90DFAA8FA77/Ventanas/IB/PI/GitHub/GNU-Radio/capturas-jose/data/data_compleja
    type: complex
    vlen: '16'
  states: {state: disabled}
- name: blocks_file_source_0_0_1
  id: blocks_file_source
  parameters:
    file: /run/media/fran/46FAA90DFAA8FA77/Ventanas/IB/PI/GitHub/DOA/test/remake_desde_csv.npy
    offset: '64'
    repeat: 'True'
    type: short
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2/8192
    type: float
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_streams_to_vector_0_1
  id: blocks_streams_to_vector
  parameters:
    num_streams: '16'
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: short
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0_0_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0_0_0_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0_0_0_0_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0_0_0_0_1
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0_0_0_0_1_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0_0_0_0_1_0_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0_0_0_0_1_0_0_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0_0_0_0_1_0_0_0_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0_0_0_0_1_0_0_0_0_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_0_0_0_0_1_0_0_0_0_0_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_1
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0_1_0
  id: hilbert_fc
  parameters:
    num_taps: 16*4
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [beamforming_beamformer_0, '0', qtgui_sink_x_0, '0']
- [beamforming_doaesprit_py_cf_0, doa_port, beamforming_beamformer_0, doa_port]
- [beamforming_doaesprit_py_cf_0, doa_port, blocks_message_debug_0, print]
- [blocks_add_const_vxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_deinterleave_0_0, '0', hilbert_fc_0, '0']
- [blocks_deinterleave_0_0, '1', hilbert_fc_0_0_0_0_0_0_0, '0']
- [blocks_deinterleave_0_0, '10', hilbert_fc_0_0_0_0_0_0_1_0_0, '0']
- [blocks_deinterleave_0_0, '11', hilbert_fc_0_0_0_0_0_0_1_0_0_0, '0']
- [blocks_deinterleave_0_0, '12', hilbert_fc_0_0_0_0_0_0_1_0_0_0_0_0, '0']
- [blocks_deinterleave_0_0, '13', hilbert_fc_0_0_0_0_0_0, '0']
- [blocks_deinterleave_0_0, '14', hilbert_fc_0_0_0_0_0_0_1_0_0_0_0_0_0, '0']
- [blocks_deinterleave_0_0, '15', hilbert_fc_0_0_0_0_0_0_1_0_0_0_0, '0']
- [blocks_deinterleave_0_0, '2', hilbert_fc_0_0_0_0_0, '0']
- [blocks_deinterleave_0_0, '3', hilbert_fc_0_0_0_0, '0']
- [blocks_deinterleave_0_0, '4', hilbert_fc_0_0_0, '0']
- [blocks_deinterleave_0_0, '5', hilbert_fc_0_0, '0']
- [blocks_deinterleave_0_0, '6', hilbert_fc_0_0_1, '0']
- [blocks_deinterleave_0_0, '7', hilbert_fc_0_0_1_0, '0']
- [blocks_deinterleave_0_0, '8', hilbert_fc_0_0_0_0_0_0_1, '0']
- [blocks_deinterleave_0_0, '9', hilbert_fc_0_0_0_0_0_0_1_0, '0']
- [blocks_file_source_0_0_1, '0', blocks_throttle_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_deinterleave_0_0, '0']
- [blocks_short_to_float_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_streams_to_vector_0_1, '0', beamforming_beamformer_0, '0']
- [blocks_streams_to_vector_0_1, '0', beamforming_doaesprit_py_cf_0, '0']
- [blocks_throttle_1, '0', blocks_short_to_float_0_0, '0']
- [hilbert_fc_0, '0', blocks_streams_to_vector_0_1, '0']
- [hilbert_fc_0_0, '0', blocks_streams_to_vector_0_1, '5']
- [hilbert_fc_0_0_0, '0', blocks_streams_to_vector_0_1, '4']
- [hilbert_fc_0_0_0_0, '0', blocks_streams_to_vector_0_1, '3']
- [hilbert_fc_0_0_0_0_0, '0', blocks_streams_to_vector_0_1, '2']
- [hilbert_fc_0_0_0_0_0_0, '0', blocks_streams_to_vector_0_1, '13']
- [hilbert_fc_0_0_0_0_0_0_0, '0', blocks_streams_to_vector_0_1, '1']
- [hilbert_fc_0_0_0_0_0_0_1, '0', blocks_streams_to_vector_0_1, '8']
- [hilbert_fc_0_0_0_0_0_0_1_0, '0', blocks_streams_to_vector_0_1, '9']
- [hilbert_fc_0_0_0_0_0_0_1_0_0, '0', blocks_streams_to_vector_0_1, '10']
- [hilbert_fc_0_0_0_0_0_0_1_0_0_0, '0', blocks_streams_to_vector_0_1, '11']
- [hilbert_fc_0_0_0_0_0_0_1_0_0_0_0, '0', blocks_streams_to_vector_0_1, '15']
- [hilbert_fc_0_0_0_0_0_0_1_0_0_0_0_0, '0', blocks_streams_to_vector_0_1, '12']
- [hilbert_fc_0_0_0_0_0_0_1_0_0_0_0_0_0, '0', blocks_streams_to_vector_0_1, '14']
- [hilbert_fc_0_0_1, '0', blocks_streams_to_vector_0_1, '6']
- [hilbert_fc_0_0_1_0, '0', blocks_streams_to_vector_0_1, '7']

metadata:
  file_format: 1
