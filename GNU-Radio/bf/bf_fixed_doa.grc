options:
  parameters:
    author: fran
    generate_options: qt_gui
    id: bf_fixed_doa
    output_language: python
    title: BF for fixed DOA
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 65e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8.125e6
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 65e6
  states: {state: disabled}
- name: beamforming_HeaderReader_0
  id: beamforming_HeaderReader
  parameters: {}
  states: {state: disabled}
- name: beamforming_beamformer_0
  id: beamforming_beamformer
  parameters:
    idx: '0'
    mx: '4'
    my: '4'
  states: {state: disabled}
- name: beamforming_doaesprit_py_cf_0
  id: beamforming_doaesprit_py_cf
  parameters:
    element_separation: 299792458/(2*19.51e6)
    fc: 19.51e6
    mx: '4'
    my: '4'
    n: '1'
    spd: '128'
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_1_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_1_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_1_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_1_0_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_1_0_0_0_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_1_0_0_0_1
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_1_0_0_1
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_1_0_1
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_1_1
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /run/media/fran/46FAA90DFAA8FA77/Ventanas/IB/Cuatri_10/labo_de_redes/sys_prog/tp-final/entrega/test_data/test_data.npy
    repeat: 'True'
    type: complex
    vlen: '16'
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /run/media/fran/46FAA90DFAA8FA77/Ventanas/IB/PI/GitHub/GNU-Radio/tests-en-labo/files/datos_preproc
    repeat: 'True'
    type: short
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_0_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_0_1_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_0_1_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_0_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_0_3
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_1_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_1_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_2_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_3
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_short_to_char_0
  id: blocks_short_to_char
  parameters: {}
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '16'
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '88'
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: '16'
  states: {state: disabled}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: short
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 192.168.0.21
    port: '12345'
    psize: '64088'
    type: short
    vlen: '1'
  states: {state: disabled}
- name: blocks_udp_source_0_0_0_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 192.168.0.21
    port: '12345'
    psize: '1432'
    type: short
    vlen: '1'
  states: {state: disabled}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '16'
    type: complex
  states: {state: disabled}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'False'
  states: {state: disabled}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: disabled}
- name: my_beamformer_beamformer_from_angles_0
  id: my_beamformer_beamformer_from_angles
  parameters:
    azimuth: '15'
    elevation: '60'
    freq: '19.51'
    separation: 299792458/19.51e6/2
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1000'
    label1: Freq
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1000'
    label1: Freq
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 436e1
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    label1: Real (t)
    size: '1000'
    srate: samp_rate
    stemplot: 'True'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    label1: Real (t)
    label2: imag (t)
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    label1: Real (t)
    label2: imag (t)
    size: '1000'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0_0_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    label1: Real (t)
    label2: imag (t)
    size: '1000'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    label1: Real (t)
    size: '1000'
    srate: samp_rate
    stemplot: 'True'
    type: float
    ylabel: Magnitud
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    label1: Real (t)
    size: '1000'
    srate: samp_rate
    stemplot: 'True'
    type: float
    ylabel: Fase
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    nconnections: '10'
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: float
  states: {state: disabled}
- name: stream_demux_stream_demux_0
  id: stream_demux_stream_demux
  parameters:
    lengths: (32000, 44)
    num_outputs: '2'
    type: short
    vlen: '1'
  states: {state: disabled}
- name: stream_demux_stream_demux_1_0
  id: stream_demux_stream_demux
  parameters:
    lengths: (672,44)
    num_outputs: '2'
    type: short
    vlen: '1'
  states: {}
- name: stream_demux_stream_demux_1_0_0
  id: stream_demux_stream_demux
  parameters:
    lengths: (1,1)
    num_outputs: '2'
    type: short
    vlen: '1'
  states: {state: disabled}

connections:
- [beamforming_beamformer_0, '0', qtgui_sink_x_0, '0']
- [beamforming_doaesprit_py_cf_0, doa_port, beamforming_beamformer_0, doa_port]
- [beamforming_doaesprit_py_cf_0, doa_port, blocks_message_debug_0, print]
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', blocks_null_sink_2, '0']
- [blocks_complex_to_float_1, '0', qtgui_time_sink_x_1, '2']
- [blocks_complex_to_float_1_0, '0', qtgui_time_sink_x_1, '3']
- [blocks_complex_to_float_1_0_0, '0', qtgui_time_sink_x_1, '5']
- [blocks_complex_to_float_1_0_0_0, '0', qtgui_time_sink_x_1, '7']
- [blocks_complex_to_float_1_0_0_0_0, '0', qtgui_time_sink_x_1, '6']
- [blocks_complex_to_float_1_0_0_0_0_0, '0', qtgui_time_sink_x_1, '9']
- [blocks_complex_to_float_1_0_0_0_1, '0', qtgui_time_sink_x_1, '4']
- [blocks_complex_to_float_1_0_0_1, '0', qtgui_time_sink_x_1, '8']
- [blocks_complex_to_float_1_0_1, '0', qtgui_time_sink_x_1, '1']
- [blocks_complex_to_float_1_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_magphase_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_sink_x_0_2_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_1, '0']
- [blocks_float_to_complex_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_complex_to_float_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_short_to_char_0, '0', blocks_null_sink_1, '0']
- [blocks_short_to_char_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_vector_0, '0', beamforming_beamformer_0, '0']
- [blocks_stream_to_vector_0, '0', beamforming_doaesprit_py_cf_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_stream_to_vector_0, '0', my_beamformer_beamformer_from_angles_0, '0']
- [blocks_stream_to_vector_1, '0', beamforming_HeaderReader_0, '0']
- [blocks_throttle_0, '0', beamforming_beamformer_0, '0']
- [blocks_throttle_0, '0', beamforming_doaesprit_py_cf_0, '0']
- [blocks_throttle_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_throttle_0, '0', my_beamformer_beamformer_from_angles_0, '0']
- [blocks_throttle_1, '0', stream_demux_stream_demux_1_0, '0']
- [blocks_udp_source_0, '0', stream_demux_stream_demux_0, '0']
- [blocks_udp_source_0_0_0_0, '0', stream_demux_stream_demux_1_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_complex_to_float_1_1, '0']
- [blocks_vector_to_streams_0, '0', blocks_null_sink_0_2_0, '0']
- [blocks_vector_to_streams_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_vector_to_streams_0, '0', qtgui_sink_x_1, '0']
- [blocks_vector_to_streams_0, '1', blocks_complex_to_float_1_0_1, '0']
- [blocks_vector_to_streams_0, '1', blocks_null_sink_0_0_1_0_0, '0']
- [blocks_vector_to_streams_0, '10', blocks_null_sink_0_0_1, '0']
- [blocks_vector_to_streams_0, '11', blocks_null_sink_0_2, '0']
- [blocks_vector_to_streams_0, '12', blocks_null_sink_0_0_0, '0']
- [blocks_vector_to_streams_0, '13', blocks_null_sink_0_1, '0']
- [blocks_vector_to_streams_0, '14', blocks_null_sink_0_0, '0']
- [blocks_vector_to_streams_0, '15', blocks_null_sink_0_0_3, '0']
- [blocks_vector_to_streams_0, '2', blocks_complex_to_float_1, '0']
- [blocks_vector_to_streams_0, '2', blocks_null_sink_0_0_1_0, '0']
- [blocks_vector_to_streams_0, '3', blocks_complex_to_float_1_0, '0']
- [blocks_vector_to_streams_0, '3', blocks_null_sink_0, '0']
- [blocks_vector_to_streams_0, '4', blocks_complex_to_float_1_0_0_0_1, '0']
- [blocks_vector_to_streams_0, '4', blocks_null_sink_0_0_0_1, '0']
- [blocks_vector_to_streams_0, '5', blocks_complex_to_float_1_0_0, '0']
- [blocks_vector_to_streams_0, '5', blocks_null_sink_0_1_1, '0']
- [blocks_vector_to_streams_0, '5', qtgui_time_sink_x_0_1_0_0_0_0_0_0, '0']
- [blocks_vector_to_streams_0, '6', blocks_complex_to_float_1_0_0_0_0, '0']
- [blocks_vector_to_streams_0, '6', blocks_null_sink_0_0_2, '0']
- [blocks_vector_to_streams_0, '7', blocks_complex_to_float_0, '0']
- [blocks_vector_to_streams_0, '7', blocks_complex_to_float_1_0_0_0, '0']
- [blocks_vector_to_streams_0, '7', blocks_null_sink_0_3, '0']
- [blocks_vector_to_streams_0, '7', qtgui_time_sink_x_0_1_0_0_0_0_0_0_0_0, '0']
- [blocks_vector_to_streams_0, '8', blocks_complex_to_float_1_0_0_1, '0']
- [blocks_vector_to_streams_0, '8', blocks_null_sink_0_0_0_0, '0']
- [blocks_vector_to_streams_0, '9', blocks_complex_to_float_1_0_0_0_0_0, '0']
- [blocks_vector_to_streams_0, '9', blocks_null_sink_0_1_0, '0']
- [my_beamformer_beamformer_from_angles_0, '0', qtgui_sink_x_0, '0']
- [stream_demux_stream_demux_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [stream_demux_stream_demux_0, '0', stream_demux_stream_demux_1_0_0, '0']
- [stream_demux_stream_demux_0, '1', blocks_short_to_char_0, '0']
- [stream_demux_stream_demux_1_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [stream_demux_stream_demux_1_0, '1', blocks_short_to_char_0, '0']
- [stream_demux_stream_demux_1_0_0, '0', blocks_short_to_float_0, '0']
- [stream_demux_stream_demux_1_0_0, '1', blocks_short_to_float_0_0, '0']

metadata:
  file_format: 1
