options:
  parameters:
    author: fran
    generate_options: qt_gui
    id: bf_fixed_doa
    output_language: python
    title: BF for fixed DOA
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: beamforming_beamformer_0
  id: beamforming_beamformer
  parameters:
    idx: '0'
    mx: '4'
    my: '4'
  states: {state: disabled}
- name: beamforming_doaesprit_py_cf_0
  id: beamforming_doaesprit_py_cf
  parameters:
    element_separation: '34379.869036697244'
    fc: 436e1
    mx: '4'
    my: '4'
    n: '1'
    spd: '128'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /run/media/fran/46FAA90DFAA8FA77/Ventanas/IB/PI/entendiendo-doa-esprit/binarios/simulated_signal_theta_30_phi_60_dos.npy
    repeat: 'True'
    type: complex
    vlen: '16'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_1_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_1_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_1_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_1_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_2_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_3
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: '16'
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '16'
    type: complex
  states: {}
- name: my_beamformer_beamformer_from_angles_0
  id: my_beamformer_beamformer_from_angles
  parameters:
    azimuth: '60'
    elevation: '30'
    freq: '436e-5'
    separation: 299792458/436e6/2
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 436e1
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 436e1
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [beamforming_beamformer_0, '0', qtgui_sink_x_0, '0']
- [beamforming_doaesprit_py_cf_0, doa_port, beamforming_beamformer_0, doa_port]
- [beamforming_doaesprit_py_cf_0, doa_port, blocks_message_debug_0, print]
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_throttle_0, '0', beamforming_beamformer_0, '0']
- [blocks_throttle_0, '0', beamforming_doaesprit_py_cf_0, '0']
- [blocks_throttle_0, '0', my_beamformer_beamformer_from_angles_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_null_sink_0_2_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_null_sink_0_0_1_0_0, '0']
- [blocks_vector_to_streams_0, '10', blocks_null_sink_0_0_1, '0']
- [blocks_vector_to_streams_0, '11', blocks_null_sink_0_2, '0']
- [blocks_vector_to_streams_0, '12', blocks_null_sink_0_0_0, '0']
- [blocks_vector_to_streams_0, '13', blocks_null_sink_0_1, '0']
- [blocks_vector_to_streams_0, '14', blocks_null_sink_0_0, '0']
- [blocks_vector_to_streams_0, '15', qtgui_sink_x_0_0, '0']
- [blocks_vector_to_streams_0, '2', blocks_null_sink_0_0_1_0, '0']
- [blocks_vector_to_streams_0, '3', blocks_null_sink_0, '0']
- [blocks_vector_to_streams_0, '4', blocks_null_sink_0_0_0_1, '0']
- [blocks_vector_to_streams_0, '5', blocks_null_sink_0_1_1, '0']
- [blocks_vector_to_streams_0, '6', blocks_null_sink_0_0_2, '0']
- [blocks_vector_to_streams_0, '7', blocks_null_sink_0_3, '0']
- [blocks_vector_to_streams_0, '8', blocks_null_sink_0_0_0_0, '0']
- [blocks_vector_to_streams_0, '9', blocks_null_sink_0_1_0, '0']
- [my_beamformer_beamformer_from_angles_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
