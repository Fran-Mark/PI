options:
  parameters:
    author: fran
    generate_options: qt_gui
    id: processing_stage
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /run/media/fran/46FAA90DFAA8FA77/Ventanas/IB/Cuatri_10/labo_de_redes/sys_prog/tp-final/entrega/captures/server_side/Tavo_2022-05-30_17-45-01
    repeat: 'True'
    type: complex
    vlen: '16'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: '16'
  states: {}
- name: my_beamformer_beamformer_from_tle_0
  id: my_beamformer_beamformer_from_tle
  parameters:
    freq: '435.95'
    line1: 1 44412U 19038AC  22276.65354806  .00016016  00000-0  77611-3 0  9991
    line2: 2 44412  97.6479 246.9046 0021697 117.1941 243.1508 15.18411127179101
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', my_beamformer_beamformer_from_tle_0, '0']
- [my_beamformer_beamformer_from_tle_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
