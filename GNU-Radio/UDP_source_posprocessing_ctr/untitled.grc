options:
  parameters:
    author: fran
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_udp_source_0_0_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 192.168.0.21
    port: '12345'
    psize: '32044'
    type: short
    vlen: '1'
  states: {state: disabled}
- name: blocks_udp_source_0_0_0_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 192.168.0.21
    port: '12345'
    psize: '716'
    type: short
    vlen: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: stream_demux_stream_demux_0_0_0
  id: stream_demux_stream_demux
  parameters:
    lengths: (44, 32000)
    num_outputs: '2'
    type: short
    vlen: '1'
  states: {state: disabled}
- name: stream_demux_stream_demux_0_0_0_0
  id: stream_demux_stream_demux
  parameters:
    lengths: (44, 672)
    num_outputs: '2'
    type: short
    vlen: '1'
  states: {}

connections:
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_udp_source_0_0_0, '0', stream_demux_stream_demux_0_0_0, '0']
- [blocks_udp_source_0_0_0_0, '0', stream_demux_stream_demux_0_0_0_0, '0']
- [stream_demux_stream_demux_0_0_0, '0', blocks_null_sink_0, '0']
- [stream_demux_stream_demux_0_0_0, '1', blocks_short_to_float_0, '0']
- [stream_demux_stream_demux_0_0_0_0, '0', blocks_null_sink_0, '0']
- [stream_demux_stream_demux_0_0_0_0, '1', blocks_short_to_float_0, '0']

metadata:
  file_format: 1
