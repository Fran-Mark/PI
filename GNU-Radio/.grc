options:
  parameters:
    author: fran
    generate_options: qt_gui
    id: dassd
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_1_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_1_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_1_3
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_1_4
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_1_5
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_3
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_4
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_5
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_6
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_7
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: '[1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1]'
    num_outputs: '16'
    type: float
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '64088'
    port: '12345'
    src_zeros: 'False'
    type: int
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_int_to_float_0, '0', blocks_stream_demux_0, '0']
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_stream_demux_0, '0', blocks_null_sink_0, '0']
- [blocks_stream_demux_0, '1', qtgui_time_sink_x_0, '0']
- [blocks_stream_demux_0, '10', blocks_null_sink_0_1_3, '0']
- [blocks_stream_demux_0, '11', blocks_null_sink_0_1_2, '0']
- [blocks_stream_demux_0, '12', blocks_null_sink_0_1_1, '0']
- [blocks_stream_demux_0, '13', blocks_null_sink_0_1_0, '0']
- [blocks_stream_demux_0, '14', blocks_null_sink_0_1_4, '0']
- [blocks_stream_demux_0, '15', blocks_null_sink_0_1_5, '0']
- [blocks_stream_demux_0, '2', blocks_null_sink_0_7, '0']
- [blocks_stream_demux_0, '3', blocks_null_sink_0_6, '0']
- [blocks_stream_demux_0, '4', blocks_null_sink_0_5, '0']
- [blocks_stream_demux_0, '5', blocks_null_sink_0_4, '0']
- [blocks_stream_demux_0, '6', blocks_null_sink_0_3, '0']
- [blocks_stream_demux_0, '7', blocks_null_sink_0_2, '0']
- [blocks_stream_demux_0, '8', blocks_null_sink_0_1, '0']
- [blocks_stream_demux_0, '9', blocks_null_sink_0_0, '0']
- [network_udp_source_0, '0', blocks_int_to_float_0, '0']

metadata:
  file_format: 1
