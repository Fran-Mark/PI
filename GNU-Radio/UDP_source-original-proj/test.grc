options:
  parameters:
    author: fran
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 162.5e3
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /run/media/fran/46FAA90DFAA8FA77/Ventanas/IB/PI/GitHub/GNU-Radio/UDP_sock_test/UDP_to_file_sink/file_py
    type: int
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /run/media/fran/46FAA90DFAA8FA77/Ventanas/IB/PI/GitHub/GNU-Radio/UDP_sock_test/UDP_to_file_sink/file_py
    repeat: 'True'
    type: int
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_int_to_float_0_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_null_sink_0_0_3
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_0_0_3_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_0_0_3_0_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_0_0_3_0_0_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_0_0_3_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_0_0_3_0_0_1
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_0_0_3_0_1
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_0_0_3_0_1_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_0_0_3_0_2
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_0_0_3_1
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_0_0_3_1_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_0_0_3_1_0_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_0_0_3_1_1
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_0_0_3_2
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_0_0_3_2_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_0_0_3_3
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_udp_source_0_0_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 192.168.0.21
    port: '12345'
    psize: '64088'
    type: int
    vlen: '1'
  states: {state: disabled}
- name: blocks_udp_source_0_0_0_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 192.168.0.21
    port: '12345'
    psize: '1432'
    type: int
    vlen: '1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    label1: Una sola señal
    size: '4096'
    srate: samp_rate
    stemplot: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    label1: Todas las señales
    size: '4096'
    srate: samp_rate
    stemplot: 'True'
    type: float
  states: {}
- name: stream_demux_stream_demux_1
  id: stream_demux_stream_demux
  parameters:
    lengths: (16000,22)
    num_outputs: '2'
    type: int
    vlen: '1'
  states: {}
- name: stream_demux_stream_demux_1_0
  id: stream_demux_stream_demux
  parameters:
    lengths: (336,22)
    num_outputs: '2'
    type: int
    vlen: '1'
  states: {state: disabled}
- name: stream_demux_stream_demux_2
  id: stream_demux_stream_demux
  parameters:
    lengths: 16*(1,)
    num_outputs: '16'
    type: int
    vlen: '1'
  states: {}

connections:
- [blocks_file_source_0, '0', stream_demux_stream_demux_1, '0']
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_int_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_udp_source_0_0_0, '0', blocks_file_sink_0, '0']
- [blocks_udp_source_0_0_0, '0', stream_demux_stream_demux_1, '0']
- [blocks_udp_source_0_0_0_0, '0', blocks_file_sink_0, '0']
- [blocks_udp_source_0_0_0_0, '0', stream_demux_stream_demux_1_0, '0']
- [stream_demux_stream_demux_1, '0', blocks_int_to_float_0_0, '0']
- [stream_demux_stream_demux_1, '0', stream_demux_stream_demux_2, '0']
- [stream_demux_stream_demux_1, '1', blocks_null_sink_1, '0']
- [stream_demux_stream_demux_1_0, '0', blocks_int_to_float_0_0, '0']
- [stream_demux_stream_demux_1_0, '0', stream_demux_stream_demux_2, '0']
- [stream_demux_stream_demux_1_0, '1', blocks_null_sink_1, '0']
- [stream_demux_stream_demux_2, '0', blocks_int_to_float_0, '0']
- [stream_demux_stream_demux_2, '0', blocks_null_sink_0_0_3_0, '0']
- [stream_demux_stream_demux_2, '1', blocks_null_sink_0_0_3, '0']
- [stream_demux_stream_demux_2, '10', blocks_null_sink_0_0_3_0_0_1, '0']
- [stream_demux_stream_demux_2, '11', blocks_null_sink_0_0_3_1_1, '0']
- [stream_demux_stream_demux_2, '12', blocks_null_sink_0_0_3_0_1_0, '0']
- [stream_demux_stream_demux_2, '13', blocks_null_sink_0_0_3_2_0, '0']
- [stream_demux_stream_demux_2, '14', blocks_null_sink_0_0_3_0_0_0_0, '0']
- [stream_demux_stream_demux_2, '15', blocks_null_sink_0_0_3_1_0_0, '0']
- [stream_demux_stream_demux_2, '2', blocks_null_sink_0_0_3_0_0, '0']
- [stream_demux_stream_demux_2, '3', blocks_null_sink_0_0_3_1, '0']
- [stream_demux_stream_demux_2, '4', blocks_null_sink_0_0_3_0_1, '0']
- [stream_demux_stream_demux_2, '5', blocks_null_sink_0_0_3_2, '0']
- [stream_demux_stream_demux_2, '6', blocks_null_sink_0_0_3_0_0_0, '0']
- [stream_demux_stream_demux_2, '7', blocks_null_sink_0_0_3_1_0, '0']
- [stream_demux_stream_demux_2, '8', blocks_null_sink_0_0_3_0_2, '0']
- [stream_demux_stream_demux_2, '9', blocks_null_sink_0_0_3_3, '0']

metadata:
  file_format: 1
