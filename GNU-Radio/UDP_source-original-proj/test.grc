options:
  parameters:
    author: fran
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_1_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_1_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_2_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_3
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '16'
    type: float
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 192.168.0.21
    port: '12345'
    psize: '1472'
    type: short
    vlen: '1'
  states: {state: disabled}
- name: blocks_udp_source_0_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 192.168.0.21
    port: '12345'
    psize: '16022'
    type: int
    vlen: '1'
  states: {state: disabled}
- name: blocks_udp_source_0_0_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 192.168.0.21
    port: '12345'
    psize: '1472'
    type: int
    vlen: '1'
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: int
  states: {state: disabled}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: '16'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: stream_demux_stream_demux_0
  id: stream_demux_stream_demux
  parameters:
    lengths: (44,31956)
    num_outputs: '2'
    type: short
    vlen: '1'
  states: {state: disabled}
- name: stream_demux_stream_demux_0_0
  id: stream_demux_stream_demux
  parameters:
    lengths: (22, 16000)
    num_outputs: '2'
    type: int
    vlen: '1'
  states: {state: disabled}

connections:
- [blocks_int_to_float_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_vector_to_streams_0, '0']
- [blocks_udp_source_0, '0', stream_demux_stream_demux_0, '0']
- [blocks_udp_source_0_0, '0', stream_demux_stream_demux_0_0, '0']
- [blocks_udp_source_0_0_0, '0', blocks_int_to_float_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_null_sink_0_2_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_null_sink_0_0_1_0_0, '0']
- [blocks_vector_to_streams_0, '10', blocks_null_sink_0_0_1, '0']
- [blocks_vector_to_streams_0, '11', blocks_null_sink_0_2, '0']
- [blocks_vector_to_streams_0, '12', blocks_null_sink_0_0_0, '0']
- [blocks_vector_to_streams_0, '13', blocks_null_sink_0_1, '0']
- [blocks_vector_to_streams_0, '14', blocks_null_sink_0_0, '0']
- [blocks_vector_to_streams_0, '15', qtgui_freq_sink_x_0, '0']
- [blocks_vector_to_streams_0, '15', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_streams_0, '2', blocks_null_sink_0_0_1_0, '0']
- [blocks_vector_to_streams_0, '3', blocks_null_sink_0, '0']
- [blocks_vector_to_streams_0, '4', blocks_null_sink_0_0_0_1, '0']
- [blocks_vector_to_streams_0, '5', blocks_null_sink_0_1_1, '0']
- [blocks_vector_to_streams_0, '6', blocks_null_sink_0_0_2, '0']
- [blocks_vector_to_streams_0, '7', blocks_null_sink_0_3, '0']
- [blocks_vector_to_streams_0, '8', blocks_null_sink_0_0_0_0, '0']
- [blocks_vector_to_streams_0, '9', blocks_null_sink_0_1_0, '0']
- [stream_demux_stream_demux_0, '0', blocks_vector_sink_x_0, '0']
- [stream_demux_stream_demux_0_0, '0', blocks_vector_sink_x_0, '0']
- [stream_demux_stream_demux_0_0, '1', blocks_int_to_float_0, '0']

metadata:
  file_format: 1
